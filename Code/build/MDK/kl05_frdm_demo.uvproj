# Keil uVision project kl05_frdm_demo.uvproj, settings and files
target 1 (ARM-ADS)
  device: MKL05Z32xxx4 Freescale Semiconductor
  cpu: IRAM(0x1FFFFC00-0x1FFFFFFF) IRAM2(0x20000000-0x20000BFF) IROM(0x0-0x07FFF) CLOCK(8000000) CPUTYPE("Cortex-M0+") ELITTLE
  output: kl05_frdm_demo_Flash +hex
  c flags: Optim=1
  c define: KEIL FRDM CMSIS
  c include: ..\..\src\projects\Inc;..\..\src\common\Inc;..\..\src\cpu\Inc;..\..\src\drivers\Inc;..\..\src\platforms
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x1ffffc00 size 0x400
  memory RVCT10: RAM 0x20000000 size 0xc00
  group project
    ../../src/projects/Src/: global.c gpio.c main.c TSIDrv.c
  group common
    ../../src/common/Src/: alloc.c assert.c io.c memtest.c queue.c stdlib.c uif.c
  group cpu
    ../../src/cpu/Src/: arm_cm0.c MDK_MKL05Z4.s nmi_isr_handler.c sysinit.c
  group drivers
    ../../src/drivers/Src/: flag.c flash.c llwu.c lptmr.c mcg.c pit.c pmc.c rcm.c Retarget.c rtc.c Serial.c uart.c
