# IAR project MoveCtrl.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKL05Z32xxx4 Freescale MKL05Z32xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: IAR; FRDM
  ICCARM.CCIncludePath2: ..\..\src\projects; ..\..\src\common; ..\..\src\cpu; ..\..\src\drivers\Inc; ..\..\src\platforms; 
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: MoveCtrl.hex
  ILINK.IlinkOutputFile: MoveCtrl.out
  ILINK.IlinkIcfFile: Configure\32KB_Pflash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Common
    ../../src/common/: alloc.c assert.c io.c memtest.c printf.c queue.c startup.c stdlib.c uif.c
  group Cpu
    ../../src/cpu/: arm_cm0.c IAR_MKL05Z4.s sysinit.c vectors.c
  group Drivers
    ../../src/drivers/Src/: flag.c flash_FTFL.c llwu.c lptmr.c mcg.c pit.c pmc.c rcm.c rtc.c smc.c uart.c
  group Project
    ../../src/projects/: freedom_gpio.c global.c main.c TSIDrv.c
